###############################################################################
# enable message level FSBL_DEBUG_DETAILED

YAML_COMPILER_FLAGS_append = " -DFSBL_DEBUG_DETAILED"
