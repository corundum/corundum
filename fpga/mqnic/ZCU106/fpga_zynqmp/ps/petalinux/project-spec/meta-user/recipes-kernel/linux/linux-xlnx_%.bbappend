SRC_URI += "file://enable_ptp.cfg\
            file://enable_dsa.cfg\
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

